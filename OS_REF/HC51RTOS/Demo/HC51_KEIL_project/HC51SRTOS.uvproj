# Keil uVision project HC51SRTOS.uvproj, settings and files
target RaySRTOS (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: HC51SRTOS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\RTOS;..\..\CPU;..\HC51_KEIL_project
  group Demo
    ./: main.c
  group CPU
    ../../CPU/: CPU.c CPU_ASM.asm
  group RTOS
    ../../RTOS/: HC51SRTOS.c
