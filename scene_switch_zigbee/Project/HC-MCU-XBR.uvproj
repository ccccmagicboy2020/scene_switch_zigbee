# Keil uVision project HC-MCU-XBR.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89S003F4 HC89S Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: HC-MCU-XBR +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../User/: HC-MCU-XBR.c mcu_api.c protocol.c system.c
